# Keil uVision project practica4.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2105 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: practica4
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
  scatter file: .\practica4.sct
  group Source Group 1
    ./: practica4.s ordena.s suma.s
